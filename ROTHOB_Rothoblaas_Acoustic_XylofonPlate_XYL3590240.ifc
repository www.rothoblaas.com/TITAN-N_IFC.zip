Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: f31d9418-93ec-435d-b3e2-9687d306a965, NumberOfSaves: 17], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_Acoustic_XylofonPlate_XYL3590240.ifc
Time: 2025-06-18T17:16:54
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcBuildingElementProxy: Collegamenti strutturali : ROTHOB_Rothoblaas_Acoustic_XylofonPlate : XYL3590240_240x90x6mm
In: 0_Rothoblaas
Type - PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_Xylofon35
Type - Generale - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_Acoustic_XylofonPlate; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-35 50 11 21 14; OmniClassTitle: Acoustic Floor Mountings; OmniClassVersion: 2012-05-16; ProductInformation: www.rothoblaas.com/products/soundproofing/resilient-profiles/xylofon-plate; Revision: 000; UniClass2015Code: Pr_20_85_85_02; UniClass2015Title: Acoustic and vibration resistant bearings; UniClass2015Version: Products v1.38; Version: 001
Type - Vincoli - ModelNumberCode: 90240; Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_Xylofon35
Type - Quote - Height_H: 6 mm; Length_L: 90 mm; Width_B: 240 mm
Type - Dati identità - Descrizione: Separating profile for timber shear bracket angles; Nome del tipo: XYL3590240_240x90x6mm; Numero OmniClass: 23.13.23.11.19.13; Produttore: info@rothoblaas.com
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_85_85_02 - Acoustic and vibration resistant bearings; CECode: ETA-11/0496; CETitle: Rotho Blaas TITAN Angle Brackets; CodePerformance: CE - Construction products; Color: Light ivory; Constituents: n/a; Description: Separating profile for timber shear bracket angles; DurationUnit: Years; ExpectedLife: n/a; Features: Profile with sound-absorbing power; Finish: n/a; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: Polyurethane; MinWeight: 0.162 kg; ModelDisclaimer: For application with Titan N TTN240 and Titan V TTV240 / The latest version of the data sheets can be found on our website; ModelNumber: XYL3590240; ModelReference: n/a; Name: Acoustic profile; Nome famiglia: ROTHOB_Rothoblaas_Acoustic_XylofonPlate; NominalHeight: 6 mm; NominalLength: 90 mm; NominalWidth: 240 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 240x90x6 mm; SustainabilityPerformance: EPDITALY0368; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Light ivory
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Acoustic profile; Category: Pr_20_85_85_02 - Acoustic and vibration resistant bearings
Type - Pset_ProvisionForVoid - Shape: Three-dimensional
Pset_BuildingElementProxyCommon - Reference: XYL3590240_240x90x6mm; sets with these values: 2
Pset_ProvisionForVoid - Width: 240 mm; Height: 90 mm; Depth: 90 mm
Vincoli - Host: Livello : 0_Rothoblaas; Livello: 0_Rothoblaas; Livello abaco: 0_Rothoblaas; Quota altimetrica da livello: 0 mm
Fasi - Fase di creazione: Stato di Progetto
Strutturale - Copriferro armatura: Copriferro armatura 1 <25 mm>
Quote - Area: 0.02358 m2; Volume: 0.0001296 m3
Altro - Famiglia: ROTHOB_Rothoblaas_Acoustic_XylofonPlate; Famiglia e tipo: ROTHOB_Rothoblaas_Acoustic_XylofonPlate: XYL3590240_240x90x6mm; ID tipo: 287311; Tipo: XYL3590240_240x90x6mm
