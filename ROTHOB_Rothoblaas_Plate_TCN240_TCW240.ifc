Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: ff7d7884-ea9f-4706-b58b-7f40ee4e8572, NumberOfSaves: 22], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_Plate_TCN240_TCW240.ifc
Time: 2025-06-23T12:23:10
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcDiscreteAccessory: Collegamenti strutturali : ROTHOB_Rothoblaas_Plate_TitanN_TCN_TCN240 : 240x123x120mm
In: 0_Rothoblaas
Type - Material: ROTHOB_Rothoblaas_CarbonSteel_DX51D-Z275
Type - Generale - Author: ROTHO BLAAS SRL; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: www.rothoblaas.com/products/fastening/brackets-and-plates/angle-brackets-and-plates-for-buildings/titan-n; Revision: 001; UniClass2015Code: Pr_20_85_09_11; UniClass2015Title: Carbon steel brackets; UniClass2015Version: Products v1.38; Version: 002
Type - Vincoli - Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_DX51D-Z275
Type - Quote - Height_H: 120 mm; HoleQuantity_nhØ13: 0; HoleQuantity_nhØ17: 4; HoleQuantity_nvØ5: 36; Length_B: 240 mm; Thickness_s: 3 mm; Width_P: 123 mm
Type - Dati identità - Descrizione: Angle bracket for shear and tensile forces; Nome del tipo: 240x123x120mm; Numero OmniClass: 23.13.23.11.19.13; Produttore: info@rothoblaas.com
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_85_09_11: Carbon steel brackets; CECode: ETA 11/0496; CETitle: Rotho Blaas TITAN Angle Brackets; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: Angle bracket for shear and tensile forces; DurationUnit: Years; ExpectedLife: 50; Features: TITAN angle bracket for timber-to-timber, timber-to-concrete, timber-to-steel joints; Finish: Zinc plated; Grade: n/a; GTIN: 8053626558624; Manufacturer: info@rothoblaas.com; Material: DX51D+Z275 zinc plated carbon steel; MinWeight: 1.279kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: TCN240; ModelReference: n/a; Name: Plate; Nome famiglia: ROTHOB_Rothoblaas_Plate_TitanN_TCN_TCN240; NominalHeight: 120 mm; NominalLength: 240 mm; NominalWidth: 123 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 240x123x120mm; SustainabilityPerformance: BVB Accepted / Sundahus A; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Plate; Category: Pr_20_85_09_11: Carbon steel brackets
Pset_QuantityTakeOff - Reference: 240x123x120mm
Vincoli - Host: Livello : 0_Rothoblaas; Livello: 0_Rothoblaas; Livello abaco: 0_Rothoblaas; Quota altimetrica da livello: 0 mm
Fasi - Fase di creazione: Stato di Progetto
Quote - Volume: 0.000167479 m3
Altro - Famiglia: ROTHOB_Rothoblaas_Plate_TitanN_TCN_TCN240; Famiglia e tipo: ROTHOB_Rothoblaas_Plate_TitanN_TCN_TCN240: 240x123x120mm; ID tipo: 303953; Tipo: 240x123x120mm

# IfcDiscreteAccessory: Collegamenti strutturali : ROTHOB_Rothoblaas_Plate_TitanWasher_TCW240 : 230x73mm
In: 0_Rothoblaas
Type - Material: ROTHOB_Rothoblaas_CarbonSteel_S235-Fe/Zn12c
Type - Visibilità - HasHole_TCW240: yes
Type - Generale - Author: ROTHO BLAAS SRL; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: n/a; Revision: 001; UniClass2015Code: Pr_20_29_03_10; UniClass2015Title: Carbon steel anchor plates; UniClass2015Version: Products v1.30; Version: 002
Type - Vincoli - Prospetto di default: 1219.2 mm; Notch: 34 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_S235-Fe/Zn12c
Type - Quote - HoleQuantity_nhØ14: 0; HoleQuantity_nhØ18: 2; Length_B: 230 mm; Thickness_s: 12 mm; Width_P: 73 mm
Type - Dati identità - Descrizione: Washer for angle brackets; Nome del tipo: 230x73mm; Numero OmniClass: 23.13.23.11.19.13; Produttore: info@rothoblaas.com
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_29_03_10: Carbon steel anchor plates; CECode: ETA 11/0496; CETitle: Rotho Blaas TITAN Angle Brackets; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: Washer for angle brackets; DurationUnit: Years; ExpectedLife: 50; Features: TITAN angle bracket for timber-to-timber, timber-to-concrete, timber-to-steel joints; Finish: Zinc plated; Grade: n/a; GTIN: 8054247478315; Manufacturer: info@rothoblaas.com; Material: S235 + Fe/Zn12c zinc plated carbon steel; MinWeight: 1.434kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: TCW240; ModelReference: n/a; Name: Plate; Nome famiglia: ROTHOB_Rothoblaas_Plate_TitanWasher_TCW240; NominalHeight: n/a; NominalLength: 230 mm; NominalWidth: 73 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 230x73mm; SustainabilityPerformance: Sundahus A; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Plate; Category: Pr_20_29_03_10: Carbon steel anchor plates
Pset_QuantityTakeOff - Reference: 230x73mm
Vincoli - Livello: 0_Rothoblaas; Livello abaco: 0_Rothoblaas; Host: ROTHOB_Rothoblaas_Plate_TitanN_TCN_TCN240 : 240x123x120mm; Quota altimetrica da livello: 3 mm
Fasi - Fase di creazione: Stato di Progetto
Quote - Volume: 0.00019232 m3
Altro - Famiglia: ROTHOB_Rothoblaas_Plate_TitanWasher_TCW240; Famiglia e tipo: ROTHOB_Rothoblaas_Plate_TitanWasher_TCW240: 230x73mm; ID tipo: 305068; Tipo: 230x73mm
